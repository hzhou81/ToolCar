# Keil uVision project bluetooth_control.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bluetooth_control +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Source\CMSIS;.\Source\FWlib\inc;.\Source\FWlib\src;.\Source\BSP;.\Source\APP;.\Source\PUBLIC\delay;.\Source\PUBLIC\sys;.\Source\PUBLIC\usart;.\Source\Protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Support
    ./Source/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ./Source/CMSIS/: system_stm32f10x.c
  group PUBLIC
    ./Source/PUBLIC/delay/: delay.c
    ./Source/PUBLIC/sys/: sys.c
    ./Source/PUBLIC/usart/: usart.c
  group APP
    ./Source/APP/: main.c app_motor.c app_linewalking.c app_iravoid.c app_lightseeking.c app_ultrasonic.c app_bluetooth.c app_buzzer.c app_colormode.c
  group Protocol
    ./Source/Protocol/: protocol.c
  group BSP
    ./Source/BSP/: bsp.c bsp_gpio.c bsp_motor.c bsp_servo.c bsp_timer.c bsp_colorful.c bsp_linewalking.c bsp_iravoid.c bsp_lightseeking.c bsp_ultrasonic.c bsp_adc.c bsp_buzzer.c bsp_fire.c bsp_gs.c
  group FWLIB
    ./Source/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
